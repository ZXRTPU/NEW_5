# Keil uVision project C_Board_Standard_Robot .uvprojx, settings and files
target C_Board_Standard_Robot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: C_Board_Standard_Robot +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT=1
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;..\Drivers\CMSIS\DSP\Include;../Drivers/CMSIS/Include;..\BSP;..\USER\Algorithm;..\USER\BMI088;..\USER\Daemon;..\USER\Judge_system;..\USER\miniPC;..\USER\RC_device;..\RTOS_task;..\Src
  asm include: ../Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c freertos.c can.c dma.c i2c.c spi.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Inc
    ../Inc/: can.h dma.h FreeRTOSConfig.h gpio.h i2c.h main.h spi.h stm32f4xx_hal_conf.h stm32f4xx_it.h tim.h usart.h usb_device.h usbd_cdc_if.h usbd_conf.h usbd_desc.h struct_typedef.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group BSP
    ../BSP/: bsp_init.h bsp_dwt.c bsp_dwt.h drv_can.c drv_can.h bsp_usart.h bsp_usart.c bsp_usb.h bsp_usb.c drv_usart.c drv_usart.h
  group USER/Algorithm
    ../USER/Algorithm/: bsp_PWM.h bsp_PWM.c QuaternionEKF.c QuaternionEKF.h controller.h controller.c kalman_filter.h kalman_filter.c user_lib.h user_lib.c CRC.c CRC.h pid.h pid.c
  group USER/BMI088
    ../USER/BMI088/: Ins_task.h Ins_task.c BMI088driver.h BMI088driver.c BMI088Middleware.h BMI088Middleware.c BMI088reg.h transfer_function.h transfer_function.c
  group USER/Daemon
    ../USER/Daemon/: daemon.h daemon.c
  group USER/Judge_system
    ../USER/Judge_system/: judge.h judge.c
  group USER/miniPC
    ../USER/miniPC/: miniPC_process.h miniPC_process.c
  group USER/RC_device
    ../USER/RC_device/: rc_potocal.h rc_potocal.c
  group RTOS_task
    ../RTOS_task/: Exchange_task.h Exchange_task.c robot_def.h robot_def.c Chassis_task.h Chassis_task.c Gimbal_task.h Gimbal_task.c Shoot_task.h Shoot_task.c
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
